# Keil uVision project qpc_nRF51822.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_template +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c misc: --c99
  c include: ..;../include;../include/driver;../include/port;../include/qm;F:/qp/qpc/include;F:\Keil_v5\ARM\Device\Nordic\nrf51822\Include;F:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\app_common;F:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\ble;F:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\ble\ble_services;F:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\s110;F:\Keil_v5\ARM\Device\Nordic\nrf51822\Include\sd_common;../src
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group startup
    F:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/templates/: system_nrf51.c
    F:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/templates/arm/: arm_startup_nrf51.s
  group main
    ../src/: main.c
  group nordic
    F:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/simple_uart/: simple_uart.c
    F:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/ble/: ble_advdata.c
    F:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/ble/ble_services/: ble_srv_common.c
  group qpc
    F:/qp/qpc/qep/source/: qmsm_ini.c qmsm_in.c qmsm_dis.c qhsm_top.c qhsm_ini.c qhsm_in.c qhsm_dis.c qfsm_ini.c qfsm_dis.c qep_pkg.h qep.c
    F:/qp/qpc/qf/source/: qa_ctor.c qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pkg.h qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qma_ctor.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_ctr.c qte_darm.c qte_rarm.c qvanilla.c
  group base
    ../src/base/: advertising.c gap.c security.c stack.c
  group driver
    ../src/driver/: interrupt.c log.c rtc1.c serial.c
  group qm
    ../src/qm/: qm_stack.c qm_gpio.c qm_security.c qm_connection.c qm_lbs.c
  group port
    ../src/port/: qpc_handler.c
  group test
    ../src/test/: test_gpio.c
  group service
    ../src/service/: ble_lbs.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_template +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
